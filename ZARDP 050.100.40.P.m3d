# KOMPAS-3D part (ZARDP 050.100.40.P.m3d)

Model tree:
1. Операция без истории:1

Texts:
  ООО ИК Энерпред-Ярдос